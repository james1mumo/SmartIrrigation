# Repository james1mumo/SmartIrrigation

File README.md:

# Smart Home Irrigation system

## What is this?
it is a system to automate the watering of plants in your home
The system consists of a microcontroller (ESP32) that is connected to a water pump,
sensors to detect moisture levels in the soil, and a relay to turn the pump on and off.
The system can be controlled locally using push buttons, or remotely using a web interface

## How to use?
1. Open a web browser and visit [jamesmumo.com](https://jamesmumo.com)

### Powering on system
On system power on you see current water status
<div style="display:flex; justify-content: space-between">

</div>

### Turning water on
After water is turned on you get notified for how long it has been running
<div style="display:flex; justify-content: space-between">

</div>

### Turning water off
Water can be turned off manually or automatically by system
<div style="display:flex; justify-content: space-between">

</div>

<p style="margin-top: 200px" />

# Hardware Assembly Progress

### tools of work

### breadboard setup

### gsm simcard addition

### power supply

### let there be light

### Future improvements
* SMS notifications
* Watering schedule
* Automatic water level detection

## KiCad design kicad_sketches/kicad_sketches.kicad_pcb

Parts:
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: PWM; PinSocket_1x10_P2.54mm_Vertical
J3, J5: Analog; PinSocket_1x08_P2.54mm_Vertical
J4: PWM; PinSocket_1x08_P2.54mm_Vertical
J6: Communication; PinSocket_1x08_P2.54mm_Vertical
J7: Digital; PinSocket_2x18_P2.54mm_Vertical
U1: LM2596S-ADJ; TO-263-5_TabPin3

Connections:
+3V3: J1.4
+5V: J1.5, J7.35, J7.36
/22: J7.33
/23: J7.34
/24: J7.31
/25: J7.32
/26: J7.29
/27: J7.30
/28: J7.27
/29: J7.28
/30: J7.25
/31: J7.26
/32: J7.23
/33: J7.24
/34: J7.21
/35: J7.22
/36: J7.19
/37: J7.20
/38: J7.17
/39: J7.18
/40: J7.15
/41: J7.16
/42: J7.13
/43: J7.14
/47: J7.10
/48: J7.7
/49: J7.8
/50: J7.5
/51: J7.6
/53: J7.4
/*2: J4.6
/*3: J4.5
/*4: J4.4
/*5: J4.3
/*6: J4.2
/*7: J4.1
/*8: J2.10
/*9: J2.9
/*10: J2.8
/*11: J2.7
/*12: J2.6
/*13: J2.5
/*44: J7.11
/*45: J7.12
/*46: J7.9
/*52: J7.3
/A0: J3.1
/A1: J3.2
/A2: J3.3
/A3: J3.4
/A4: J3.5
/A5: J3.6
/A6: J3.7
/A7: J3.8
/A8: J5.1
/A9: J5.2
/A10: J5.3
/A11: J5.4
/A12: J5.5
/A13: J5.6
/A14: J5.7
/A15: J5.8
/AREF: J2.3
/IOREF: J1.2
/RX0/0: J4.8
/RX1/19: J6.6
/RX2/17: J6.4
/RX3/15: J6.2
/SCL/21: J2.1, J6.8
/SDA/20: J2.2, J6.7
/TX0/1: J4.7
/TX1/18: J6.5
/TX2/16: J6.3
/TX3/14: J6.1
/~RESET: J1.3
GND: J1.6, J1.7, J2.4, J7.1, J7.2
VCC: J1.8

Notes on the sheet:
* Indicates a PWM-capable pin

Board: 2 copper layers, 14 parts (0 on the bottom side), 4 nets, no tracks yet.

Other parts of the board:
MH1, MH2, MH3, MH4, MH5, MH6: MountingHole_3.2mm

## Commit log

2024-09-21 initial template
2024-09-22 can receive sms and reply generically
2024-09-22 receives SMS commands and replies appropriately
2024-09-24 added buzzer and push button
2024-09-25 added get stats sms command
2024-09-28 change to 4g module sim808
2024-09-28 switched to esp32 using WiFi and MQTT
2024-09-28 added web html files
2024-09-28 moved web files to /docs folder
2024-09-28 added readme and images
2024-10-04 new wifi credintials
